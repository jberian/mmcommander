<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>1</parallelThreads>
        </cstatargs>
        <cstatsettings/>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Headers</name>
    <file>
      <name>$PROJ_DIR$\configuration.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\constants.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\crc_4b6b.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\globals.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal_cc8051.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal_defs.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hal_types.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\init.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\interrupts.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ioCCxx10_bitdef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\txFilter.h</name>
    </file>
  </group>
  <group>
    <name>Sources</name>
    <group>
      <name>USB</name>
      <file>
        <name>$PROJ_DIR$\usb\others\clock.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\usb\others\hal_board.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\usb\others\hal_int.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\usb\others\hal_mcu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\usb\others\hal_uart_usb.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\usb\class_cdc\usb_cdc_descriptor.s51</name>
      </file>
      <file>
        <name>$PROJ_DIR$\usb\class_cdc\usb_cdc_hooks.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\usb\library\usb_descriptor_parser.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\usb\class_cdc\usb_firmware_library_config.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\usb\library\usb_framework.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\usb\library\usb_interrupt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\usb\library\usb_standard_requests.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\usb\library\usb_suspend.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\usb\class_cdc\usb_uart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\usb\others\util_buffer.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\crc_4b6b.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\interrupts.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\medtronicRF.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\MMCommander.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\txFilter.c</name>
    </file>
  </group>
</project>


